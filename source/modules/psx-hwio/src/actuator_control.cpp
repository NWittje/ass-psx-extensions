#include "hwio/actuator_control.hpp"
#include "hwio/runtime.hpp"
#include <cstring>
namespace hwio {
static_assert(sizeof(ActuatorControl)<8192,"Mutation receipt cache must remain small");
namespace {
namespace a=psx::hwio::actuators;namespace m=psx::hwio::motors;
template<std::size_t N>void text(std::array<char,N>& dst,const std::string& src){dst={};std::copy_n(src.begin(),std::min(src.size(),N-1),dst.begin());}
}
ActuatorControl::ActuatorControl(Runtime& runtime,std::uint64_t session):runtime_(runtime),session_(session){}
a::Packet ActuatorControl::status(){a::Packet p;p.session=session_;const auto old=runtime_.motor_mappings().motor_status_v2(session_);p.revision=old.revision;const auto [host,port]=runtime_.endpoint();text(p.host,host);p.port=port;
    auto mix=[&](std::uint64_t v){p.revision=(p.revision^v)*1099511628211ull;};mix(runtime_.actuators().revision());mix(runtime_.steppers().revision());mix(runtime_.servos().source_revision());const auto gauges=runtime_.actuators().definitions();
    for(unsigned n=0;n<a::slots;++n){auto& s=p.motors[n];s.kind=a::Kind(n/20);s.slot=n%20;s.operation_id=operations_[n];
        if(n<20){std::memcpy(&s,&old.motors[n],sizeof(m::Status));const auto v=runtime_.motor_bench().snapshot(n);s.position=v.live.position;s.target=v.live.target;s.minimum=v.live.applied.minimum;s.maximum=v.live.applied.maximum;s.reference=v.live.feedback_valid?a::Reference::measured:a::Reference::none;}
        else if(n<40){const auto v=runtime_.servos().snapshot(n-20);s.generation=v.live.generation;s.position=v.live.profile_position.value_or(v.live.accepted.value_or(0));s.target=v.live.accepted.value_or(0);s.minimum=v.draft.parameters.pulse_min;s.maximum=v.draft.parameters.pulse_max;s.reference=v.live.attached?a::Reference::pulse_command:a::Reference::none;s.flags=(v.draft.address.assigned()?m::assigned:0)|(!v.draft.at_min || !v.draft.at_max?m::homing_required:0)|(v.live.drive==MotorDriveState::off?m::release_confirmed:0);s.phase=v.phase==ServoPhase::following?m::Phase::following:v.phase==ServoPhase::fault || v.phase==ServoPhase::detached?m::Phase::fault:m::Phase::stopped;s.fault_revision=v.live.revision+(std::hash<std::string>{}(v.live.fault));if(s.phase==m::Phase::fault)s.flags|=m::major_fault;text(s.cause,v.status);
            if(resetting_[n]){if(v.phase==ServoPhase::following && v.live.drive==MotorDriveState::on)resetting_[n]=false;else if(v.phase==ServoPhase::fault || v.phase==ServoPhase::source_unavailable || v.phase==ServoPhase::detached){resetting_[n]=false;s.flags|=m::reset_failed;}else s.flags|=m::reset_pending;}}
        else{const auto v=runtime_.steppers().snapshot(n-40);s.generation=v.live.generation;s.position=v.live.position;s.target=v.live.target;s.minimum=v.live.applied.minimum;s.maximum=v.live.applied.maximum;s.flags=(v.draft.address.assigned()?m::assigned:0)|m::homing_required|(v.live.drive==MotorDriveState::off?m::release_confirmed:0);s.phase=v.live.fault.empty()?m::Phase::stopped:m::Phase::fault;if(!v.live.fault.empty())s.flags|=m::major_fault;s.fault_revision=v.live.configuration_revision+std::hash<std::string>{}(v.live.fault);s.reference=v.draft.run_mode && v.live.feedback_valid?a::Reference::measured:a::Reference::none;text(s.cause,v.status);}
        for(unsigned j=0;j<actuator_mapping_slots;++j)if(gauges[j].enabled && unsigned(gauges[j].output.kind)==unsigned(s.kind) && gauges[j].output.slot==s.slot){const auto v=runtime_.actuators().snapshot(j);const bool physically_released=(s.flags&m::release_confirmed)!=0;s.flags=m::assigned|(v.referenced?0:m::homing_required)|(physically_released?m::release_confirmed:0)|(v.reset_pending?m::reset_pending:0)|(v.major_fault?m::major_fault:0);s.fault_revision=v.fault_revision;s.operation_id=v.operation_id;s.phase=v.phase==ActuatorPhase::homing?m::Phase::homing:v.phase==ActuatorPhase::following?m::Phase::following:v.phase==ActuatorPhase::fault?m::Phase::fault:v.phase==ActuatorPhase::holding || v.phase==ActuatorPhase::waiting?m::Phase::waiting:m::Phase::stopped;s.reference=a::Reference(unsigned(v.quality));s.position=v.position;s.target=v.target;text(s.cause,v.status);break;}
    }return p;
}
a::Packet ActuatorControl::dispatch(const a::Packet& request){auto reply=status();reply.operation=request.operation;reply.request_id=request.request_id;reply.motor=request.motor;reply.kind=request.kind;reply.operation_id=request.request_id;
    if(!a::valid(request) || (request.operation!=a::Operation::status && !request.request_id)){reply.result=a::Result::malformed;return reply;}if(request.operation==a::Operation::status)return reply;
    for(const auto& old:replies_)if(old.request_id==request.request_id && old.session==request.session){if(old.kind!=request.kind || old.motor!=request.motor || old.operation!=request.operation || old.fault_revision!=request.fault_revision || old.revision!=request.revision){reply.result=a::Result::conflict;return reply;}reply.result=old.result;reply.operation_id=old.operation_id;reply.message=old.message;return reply;}
    const unsigned flat=unsigned(request.kind)*20+request.motor;
    if(request.session!=session_)reply.result=a::Result::session_mismatch;
    else if(request.request_id<=highwater_ || request.revision!=reply.revision || (request.operation==a::Operation::reset_home && request.fault_revision!=reply.motors[flat].fault_revision))reply.result=a::Result::conflict;
    else{highwater_=request.request_id;operations_[flat]=request.request_id;const auto defs=runtime_.actuators().definitions();unsigned mapping=actuator_mapping_slots;for(unsigned n=0;n<actuator_mapping_slots;++n)if(defs[n].enabled && unsigned(defs[n].output.kind)==unsigned(request.kind) && defs[n].output.slot==request.motor){mapping=n;break;}std::string error;bool ok=true;
        if(mapping<actuator_mapping_slots){if(request.operation==a::Operation::stop){runtime_.actuators().stop(mapping,request.request_id);if(request.kind==a::Kind::motor && runtime_.motor_bench().snapshot(request.motor).manual_page)runtime_.motor_bench().disengage(request.motor);if(request.kind==a::Kind::stepper && runtime_.steppers().snapshot(request.motor).bench)runtime_.steppers().stop(request.motor);if(request.kind==a::Kind::servo && !runtime_.servos().external_active(request.motor))runtime_.servos().stop(request.motor);}else ok=runtime_.actuators().home(mapping,request.request_id,request.fault_revision,error);}
        else if(request.kind==a::Kind::motor){if(request.operation==a::Operation::stop)runtime_.motor_mappings().stop(request.motor,request.request_id);else ok=runtime_.motor_mappings().reset_home(request.motor,request.fault_revision,request.request_id,error);}
        else if(request.operation==a::Operation::stop){if(request.kind==a::Kind::servo)runtime_.servos().stop(request.motor);else runtime_.steppers().stop(request.motor);resetting_[flat]=false;}
        else if(request.kind==a::Kind::servo){const auto v=runtime_.servos().snapshot(request.motor);if(!v.draft.at_min || !v.draft.at_max){ok=false;error="Capture the servo finite range first";}else{runtime_.servos().follow(request.motor);resetting_[flat]=true;}}
        else{ok=false;error="Assign stepper feedback or Home switches first";}
        if(!ok){reply.result=a::Result::unavailable;text(reply.message,error);}reply.fault_revision=request.fault_revision;replies_[cursor_++%replies_.size()]=reply;
    }return reply;
}
}
